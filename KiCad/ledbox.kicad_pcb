# Repository fabiangeissler/robosax-ledbox (continued)

## KiCad design LED Box KiCad/ledbox.kicad_pcb (continued)

Parts:
C301: 10u; C_0805
C302: 100n; C_0805
D301: LRTBG6TG; LED-6-BIG
D302: LED1; LED_0805
D303: LED2; LED_0805
J301: IR LED; Pin_Header_Straight_1x03
J302: Button; Pin_Header_Straight_1x02
R301, R302, R303, R310: 10k; R_0805
R304: 150; R_0805
R305, R311: 82; R_0805
R306, R307: 22; R_0805
R308, R309: 430; R_0805
SW301: Reset; SW_PUSH_6mm_h5mm
SW302: Push 1; SW_PUSH_6mm_h5mm
SW303: Push 2; SW_PUSH_6mm_h5mm
U301: ULN2003; SOIC-16_3.9x9.9mm_Pitch1.27mm

Connections:
+5V: C301.1, C302.1, D301.1 (RA), D301.3 (GA), D301.4 (BA), D302.2 (A), D303.2 (A), J301.1, J301.3, R301.1, R302.1, R303.1, R310.1; also elsewhere on the board
/Controller/BTN: J302.1, R310.2; also elsewhere on the board
/Controller/LED1: R308.2; also elsewhere on the board
/Controller/LED2: R309.2; also elsewhere on the board
/Controller/LED_IR: U301.1 (I1); also elsewhere on the board
/Controller/PUSH1: R302.2, SW302.1; also elsewhere on the board
/Controller/PUSH2: R303.2, SW303.1; also elsewhere on the board
/Controller/PWM_B: U301.6 (I6), U301.7 (I7); also elsewhere on the board
/Controller/PWM_G: U301.4 (I4), U301.5 (I5); also elsewhere on the board
/Controller/PWM_R: U301.2 (I2), U301.3 (I3); also elsewhere on the board
/Controller/~RESET: R301.2, SW301.1; also elsewhere on the board
/Interface/IR_LED_DRV: J301.2, R304.1
GND: C301.2, C302.2, J302.2, SW301.2, SW302.2, SW303.2, U301.8 (GND); also elsewhere on the board
unnamed: D301.2 (GK), R306.1
unnamed: D301.5 (BK), R307.1
unnamed: D301.6 (RK), R305.1, R311.1
unnamed: D302.1 (K), R308.1
unnamed: D303.1 (K), R309.1
unnamed: R304.2, U301.16 (O1)
unnamed: R305.2, R311.2, U301.14 (O3), U301.15 (O2)
unnamed: R306.2, U301.12 (O5), U301.13 (O4)
unnamed: R307.2, U301.10 (O7), U301.11 (O6)

Parts:
C401, C402, C403, C404, C405, C407: 100n; C_0805
C408, C409: 22p; C_0805
CON401: AVR_ISP; Pin_Header_Straight_2x03
J401: Power; Socket_Strip_Straight_2x03
J402: Power; Socket_Strip_Straight_2x04
J403: Power; Socket_Strip_Straight_2x05
J404: Port D; Socket_Strip_Straight_1x03
J405: Port B; Socket_Strip_Straight_1x04
J406: Port C; Socket_Strip_Straight_1x05
J407: ADC6; Socket_Strip_Straight_1x03
J408: ADC7; Socket_Strip_Straight_1x03
R401, R402, R403: 1k; R_0805
U401: ATMEGA88-20AU; TQFP-32_7x7mm_Pitch0.8mm
Y401: 20MHz; Crystal_HC49-SD_SMD

Connections:
+5V: C402.1, C403.1, C404.1, C405.1, C407.1, CON401.2, J401.1, J401.3, J401.5, J402.1, J402.3, J402.5, J402.7, J403.1, J403.3, J403.5, J403.7, J403.9, J407.1, J408.1, U401.4 (VCC), U401.6 (VCC), U401.18 (AVCC); also elsewhere on the board
/Bus/AIN0: U401.10 ((PCINT22/OC0A/AIN0)PD6); also elsewhere on the board
/Bus/AIN1: U401.11 ((PCINT23/AIN1)PD7); also elsewhere on the board
/Bus/RX: J404.1, U401.30 ((PCINT16/RXD)PD0); also elsewhere on the board
/Bus/TX: J404.2, U401.31 ((PCINT17/TXD)PD1); also elsewhere on the board
/Bus/TX_EN: U401.23 ((PCINT8/ADC0)PC0); also elsewhere on the board
/Controller/ADC6: J407.2, U401.19 (ADC6)
/Controller/ADC7: J408.2, U401.22 (ADC7)
/Controller/BTN: U401.2 ((PCINT20/XCK/T0)PD4); also elsewhere on the board
/Controller/LED1: J406.2, U401.25 ((PCINT10/ADC2)PC2); also elsewhere on the board
/Controller/LED2: J406.3, U401.26 ((PCINT11/ADC3)PC3); also elsewhere on the board
/Controller/LED_IR: U401.9 ((PCINT21/OC0B/T1)PD5); also elsewhere on the board
/Controller/MISO: CON401.1, R403.2, U401.16 ((PCINT4/MISO)PB4)
/Controller/MOSI: CON401.4, R401.2, U401.15 ((PCINT3/OC2/MOSI)PB3)
/Controller/PB0: J405.1, U401.12 ((PCINT0/CLKO/ICP1)PB0)
/Controller/PB3: J405.2, R401.1
/Controller/PB4: J405.3, R403.1
/Controller/PB5: J405.4, R402.1
/Controller/PC1: J406.1, U401.24 ((PCINT9/ADC1)PC1)
/Controller/PD2: J404.3, U401.32 ((PCINT18/INT0)PD2)
/Controller/PUSH1: J406.4, U401.27 ((PCINT12/SDA/ADC4)PC4); also elsewhere on the board
/Controller/PUSH2: J406.5, U401.28 ((PCINT13/SCL/ADC5)PC5); also elsewhere on the board
/Controller/PWM_B: U401.1 ((PCINT19/OC2B/INT1)PD3); also elsewhere on the board
/Controller/PWM_G: U401.13 ((PCINT1/OC1A)PB1); also elsewhere on the board
/Controller/PWM_R: U401.14 ((PCINT2/OC1B/~SS~)PB2); also elsewhere on the board
/Controller/SCK: CON401.3, R402.2, U401.17 ((PCINT5/SCK)PB5)
/Controller/XTAL1: C408.1, U401.7 ((PCINT6/XTAL1/TOSC1)PB6), Y401.1
/Controller/XTAL2: C409.1, U401.8 ((PCINT7/XTAL2/TOSC2)PB7), Y401.2
/Controller/~RESET: CON401.5, U401.29 ((PCINT14/~RESET~)PC6); also elsewhere on the board
GND: C401.1, C402.2, C403.2, C404.2, C405.2, C407.2, C408.2, C409.2, CON401.6, J401.2, J401.4, J401.6, J402.2, J402.4, J402.6, J402.8, J403.2, J403.4, J403.6, J403.8, J403.10, J407.3, J408.3, U401.3 (GND), U401.5 (GND), U401.21 (GND); also elsewhere on the board
unnamed: C401.2, U401.20 (AREF)

Notes on the sheet:
Hier kann ggf ein 20 MHz Quarz genutzt werden. Interner RC Oszillator: 8MHz±10% (±2% kalibriert)
RX und BTN können über PCINT den Controller aus dem IDLE Zustand wecken.
SPI Programmer
Analog Comparator wird verwendet

Parts:
C501: 4u7; CP_Radial_D5.0mm_P2.00mm
C502, C503: 100n; C_0805
C504: 47u; CP_Radial_D6.3mm_P2.50mm
D501: 1N4148; D_SOD-123
D502: LED2; LED_0805
J501: 6.5V-12V; TerminalBlock_Pheonix_MKDS1.5-2pol
J502: 5V; TerminalBlock_Pheonix_MKDS1.5-2pol
R501: 430; R_0805
U501: AZ1117-5.0; SOT-223-3Lead_TabPin2

Connections:
+5V: C503.1, C504.1, D501.2 (A), D502.2 (A), J502.1, U501.2 (VO); also elsewhere on the board
+12V: C501.1, C502.1, D501.1 (K), J501.1, U501.3 (VI)
GND: C501.2, C502.2, C503.2, C504.2, J501.2, J502.2, R501.2, U501.1 (GND); also elsewhere on the board
unnamed: D502.1 (K), R501.1

Board: 2 copper layers, 80.0 x 50.0 mm, 69 parts (14 on the bottom side), 46 nets.

File ledbox-bom.xlsx:

RoboSAX LED box
Item | Reference(s) | Value | LibPart | Footprint | Footprint | Datasheet | Populate | Qty | Part Supplier | Elecrow ID | Elecrow Part | Elecrow Value | Supplier link | Price Piece | Price Sum
1 | C201; C301 | 10u | device:C | Capacitors_SMD:C_0805 | 0805 |  |  | 2 | Elecrow | 16532 | C15850 | 10uF (106) ±10% 25V |  | 0 | 0
2 | C202; C408; C409 | 22p | device:C | Capacitors_SMD:C_0805 | 0805 |  | Prototype | 3 | Elecrow | 2156 | C1804 | 22pF (220) ±5% 50V |  | 0 | 0
3 | C203 | 470p | device:C | Capacitors_SMD:C_0805 | 0805 |  |  | 1 | Elecrow | 2095 | C1743 | 470pF (471) ±10% 50V |  | 0 | 0
4 | C302; C401; C402; C403; C404; C405; C407; C502; C503 | 100n | device:C | Capacitors_SMD:C_0805 | 0805 |  |  | 9 | Elecrow | 50686 | C49678 | 100nF(104) ±10% 50V |  | 0 | 0
5 | C501 | 4u7 | device:CP | Capacitors_THT:CP_Radial_D5.0mm_P2.00mm |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
6 | C504 | 47u | device:CP | Capacitors_THT:CP_Radial_D6.3mm_P2.50mm |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
7 | CON401 | AVR_ISP | atmel:AVR-ISP-6 | Pin_Headers:Pin_Header_Straight_2x03 |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
8 | D201; D202; D501 | 1N4148 | device:D | Diodes_SMD:D_SOD-123 | SOD-123 |  |  | 3 | Digikey |  |  |  | https://www.digikey.de/product-detail/de/smc-diode-solutions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 | 0.03872 | 0.11616
9 | D301 | changes | RGB LED |  |  |  |  | 1 | Digikey |  |  |  |  | 0.5 | 0.5
10 | D302 | LED1 | device:LED | LEDs:LED_0805 | 0805 |  |  | 1 | Digikey |  |  |  | https://www.digikey.de/product-detail/de/lite-on-inc/LTST-C1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 | 0.0608 | 0.0608
11 | D303; D502 | LED2 | device:LED | LEDs:LED_0805 | 0805 |  |  | 2 | Digikey |  |  |  | https://www.digikey.de/product-detail/de/lite-on-inc/LTST-C1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 | 0.0608 | 0.1216
12 | J201 | Bus | ledbox-cache:Conn_02x05_Odd_Even | Pin_Headers:Pin_Header_Straight_2x05 |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
13 | J301 | IR LED | ledbox-cache:Conn_01x03 | Pin_Headers:Pin_Header_Straight_1x03 |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
14 | J302 | Button | ledbox-cache:Conn_01x02 | Pin_Headers:Pin_Header_Straight_1x02 |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
15 | J401 | Power | ledbox-cache:Conn_02x03_Odd_Even | Socket_Strips:Socket_Strip_Straight_2x03 |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
16 | J402 | Power | ledbox-cache:Conn_02x04_Odd_Even | Socket_Strips:Socket_Strip_Straight_2x04 |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
17 | J403 | Power | ledbox-cache:Conn_02x05_Odd_Even | Socket_Strips:Socket_Strip_Straight_2x05 |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
18 | J404 | Port D | ledbox-cache:Conn_01x03 | Socket_Strips:Socket_Strip_Straight_1x03 |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
19 | J405 | Port B | ledbox-cache:Conn_01x04 | Socket_Strips:Socket_Strip_Straight_1x04 |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
20 | J406 | Port C | ledbox-cache:Conn_01x05 | Socket_Strips:Socket_Strip_Straight_1x05 |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
21 | J407 | ADC6 | ledbox-cache:Conn_01x03 | Socket_Strips:Socket_Strip_Straight_1x03 |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
22 | J408 | ADC7 | ledbox-cache:Conn_01x03 | Socket_Strips:Socket_Strip_Straight_1x03 |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
23 | J501 | 6.5V-12V | ledbox-cache:Conn_01x02 | Connectors_Terminal_Blocks:TerminalBlock_Pheonix_MKDS1.5-2pol |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
24 | J502 | 5V | ledbox-cache:Conn_01x02 | Connectors_Terminal_Blocks:TerminalBlock_Pheonix_MKDS1.5-2pol |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
25 | R201; R203; R401; R402; R403 | 1k | device:R | Resistors_SMD:R_0805 | 0805 |  | Prototype | 5 | Elecrow | 18201 | C17513 | 1KΩ (1001) ±1% |  | 0 | 0
26 | R202 | 150Ω | device:R | Resistors_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal |  |  | Prototype | 1 | DNP |  |  |  |  | 0 | 0
27 | R204; R301; R302; R303; R310 | 10k | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 5 | Elecrow | 18102 | C17414 | 10KΩ (1002) ±1% |  | 0 | 0
28 | R205 | 100Ω | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 1 | Elecrow | 18096 | C17408 | 100Ω (1000) ±1% |  | 0 | 0
29 | R206 | 22k | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 1 | Elecrow | 18248 | C17560 | 22KΩ (2202) ±1% |  | 0 | 0
30 | R207 | 3k3 | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 1 | Digikey |  |  |  | https://www.digikey.de/product-detail/de/stackpole-electroni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 | 0.0054 | 0.0054
31 | R208 | 2k2 | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 1 | Digikey |  |  |  | https://www.digikey.de/product-detail/de/stackpole-electroni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 | 0.0054 | 0.0054
32 | R304 | 150Ω | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 1 | Elecrow | 18159 | C17471 | 150Ω (1500) ±1% |  | 0 | 0
33 | R305; R311 | 82Ω | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 2 | Elecrow | 18529 | C17841 | 82Ω (82R0) ±1% |  | 0 | 0
34 | R306; R307 | 22Ω | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 2 | Elecrow | 18249 | C17561 | 22Ω (22R0) ±1% |  | 0 | 0
35 | R308; R309; R501 | 430Ω | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 3 | Digikey |  |  |  | https://www.digikey.de/product-detail/de/stackpole-electroni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 | 0.0054 | 0.0162
36 | SW301 | Reset | ledbox-cache:SW_Push | Buttons_Switches_THT:SW_PUSH_6mm_h5mm |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
37 | SW302 | Push 1 | ledbox-cache:SW_Push | Buttons_Switches_THT:SW_PUSH_6mm_h5mm |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
38 | SW303 | Push 2 | ledbox-cache:SW_Push | Buttons_Switches_THT:SW_PUSH_6mm_h5mm |  |  |  | 1 | DNP |  |  |  |  | 0 | 0
39 | U201 | ST485C | ledbox-newsymbols:SN75176B | Housings_SOIC:SOIC-8_3.9x4.9mm_Pitch1.27mm | SOIC 8 | http://www.st.com/content/ccc/resource/technical/document/da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 | Yes | 1 | Digikey |  |  |  | https://www.digikey.de/product-detail/de/stmicroelectronics/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 | 0.4669 | 0.4669
40 | U301 | ULN2003 | interface:ULN2003 | Housings_SOIC:SOIC-16_3.9x9.9mm_Pitch1.27mm | SOIC 16 | http://www.ti.com/lit/ds/symlink/ulq2004a.pdf |  | 1 | Digikey |  |  |  | https://www.digikey.de/product-detail/de/on-semiconductor/UL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 | 0.2241 | 0.2241
41 | U401 | ATMEGA88A-AU | atmel:ATMEGA88A-AU | Housings_QFP:TQFP-32_7x7mm_Pitch0.8mm | TQFP 32 |  |  | 1 | Digikey |  |  |  | https://www.digikey.de/product-detail/de/microchip-technolog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 | 1.0573 | 1.0573
42 | U501 | AZ1117-5.0 | regul:AZ1117-5.0 | TO_SOT_Packages_SMD:SOT-223-3Lead_TabPin2 | SOT 223 |  |  | 1 | Digikey |  |  |  | https://www.digikey.de/product-detail/de/diodes-incorporated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 | 0.1451 | 0.1451
43 | Y401 | 20MHz | device:Crystal | Crystals:Crystal_HC49-SD_SMD | HC49/SU |  | Prototype | 1 | Digikey |  |  |  | https://www.digikey.de/product-detail/de/abracon-llc/ABLS-20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 | 0.1504 | 0.1504
 |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 2.86936

## Code that names these connections

File Software/ledbox_test/main.c:

/*
 * main.c
 *
 *  Created on: 13.11.2017
 *      Author: fabian
 */

// Pinbelegung (LED BOX V.3)
// Header	Pin	Port	Signal		Flachbandkabel Pin (0 = rot)
// J406		1	PC1	CLK		1
// 		2	PC2	LED_DATA_OUT	9
// 		3	PC3	IR_CLK		5
//		4	PC4	BTN_LOAD	6
//		5	PC5	BTN_DATA_IN	7
// J404		1	PD0	LED_LOAD	8
//		2	PD1	RGB_DATA	3

#define F_CPU 20000000

#include "stdbool.h"
#include "stdint.h"

#include "util/delay.h"
#include "avr/io.h"
#include "avr/interrupt.h"

#define LEN 21

uint8_t _data[LEN] = { 0x0F, 0, 0,
						0x0F, 0, 0,
						0x0F, 0, 0,
						0x0F, 0, 0,
						0x0F, 0, 0,
						0x0F, 0, 0,
						0x0F, 0, 0,
						0x0F, 0, 0 }; // 3 LED color data

#define LED_T0H	8 	// Cycles for 0 bit high period @ 20MHz
#define LED_T1H	16 	// Cycles for 1 bit high period @ 20MHz
#define LED_TS	237	// Maximum Cycles for the whole bit period @ 20MHz

#define delay	500

// assembler code for bitbanging RGB data transmission
// defined inled_data.S
extern void send_data(uint8_t *data, uint8_t size);

// rotate data array
void circle()
{
	uint8_t d = _data[0];

	for(int i =1; i < LEN; ++i)
		_data[i - 1] = _data[i];

	_data[LEN-1] = d;
}

// -------------------------------------------------------------------------------------------
// UART RGB LED data transmission
// -------------------------------------------------------------------------------------------

volatile uint8_t bitcounter = 0;
volatile uint8_t bitmax = LEN * 8;

ISR(USART_UDRE_vect)
{
	uint8_t word = 0;
	uint8_t bc = bitcounter;

	if(bc >= bitmax)
	{
		// deactivate
		UCSR0B &= ~(1 << TXEN0);
		return;
	}

	uint8_t bit = ((_data[bc / 8] >> (7 - (bc % 8))) & 1);

	if(bit)
		word |= 0b10;
	else
		word |= 0b11;

	++bc;

	if(bc == bitmax)
	{
		// deactivate
		UCSR0B &= ~(1 << TXEN0);
		goto end;
	}

	bit = ((_data[bc / 8] >> (7 - (bc % 8))) & 1);

	if(bit)
		word |= 0b10000;
	else
		word |= 0b11000;

	++bc;

	if(bc == bitmax)
	{
		// deactivate
		UCSR0B &= ~(1 << TXEN0);
		goto end;
	}

	bit = ((_data[bc / 8] >> (7 - (bc % 8))) & 1);

	if(!bit)
		word |= 0b1000000;

	++bc;

	if(bc == bitmax)
	{
		// deactivate
		UCSR0B &= ~(1 << TXEN0);
		goto end;
	}

end:
	UDR0 = word;
	bitcounter = bc;
}

void enableRGBUART()
{
	UCSR0A |= (1 << U2X0);
	UCSR0B |= (1 << UDRIE0) /*| (1 << TXEN0)*/;
	UCSR0C = (1 << UCSZ01);
	UBRR0H = 0;
	UBRR0L = 0;
}

void start()
{
	bitcounter = 0;
	UCSR0B |=  (1 << TXEN0);
}

// -------------------------------------------------------------------------------------------
// Soft SPI IR led & button communication
// -------------------------------------------------------------------------------------------

void sendLEDdata(uint8_t *data, uint8_t *btn, uint8_t bitsize)
{
	// set load low
	PORTD &= ~(1 << 0);

	// trigger btn load
	PORTC |= (1 << 4);

	//clk low
	PORTC &= ~(1 << 1);

	// some delay
	_delay_us(0.1);

	// clk high
	PORTC |= (1 << 1);

	// some delay
	_delay_us(0.1);

	// set btn load low
	PORTC &= ~(1 << 4);

	for(uint8_t i = 0; i < bitsize; ++i)
	{
		//clk low
		PORTC &= ~(1 << 1);

		btn[i / 8] = ((PINC >> 5) & 1) << (i % 8);

		uint8_t bit = (data[i / 8] >> (i % 8)) & 1;

		// set bit output
		if(bit)
			PORTC |= (1 << 2);
		else
			PORTC &= ~(1 << 2);

		// some delay
		_delay_us(0.1);

		// clk high
		PORTC |= (1 << 1);

		// some delay
		_delay_us(0.1);
	}

	// trigger load
	PORTD |= (1 << 0);
}

int main()
{
	DDRC &= ~0b100000;
	DDRC |=  0b011110;

	DDRD |= 0b11;

	PORTD |= 0b10;

	uint8_t d = 0xAA;

	//sei();

	//enableRGBUART();

	while(1)
	{
		send_data(_data, LEN);
//		_data[0] = 0xAA;
//		_data[1] = 0xAA;
//		_data[2] = 0xAA;
//		_data[3] = 0xAA;
//		_data[4] = 0xAA;
//		_data[5] = 0xAA;

		start();

		sendLEDdata(&d, &d, 4);

		for(int i = 0; i < 10; ++i)
		{
			_delay_ms(50);
			PORTC ^= (1 << 3);
		}

		circle();

		d ^= 0xFF;

//		send_data(_data, LEN);
//
//		_data[0] = 0x55;
//		_data[3] = 0x55;
//		_delay_ms(delay);
//		send_data(_data, LEN);
//
//		_data[1] = 0x55;
//		_data[4] = 0x55;
//		_delay_ms(delay);
//		send_data(_data, LEN);
//
//		_data[2] = 0x55;
//		_data[5] = 0x55;
//		_delay_ms(delay);
//		send_data(_data, LEN);
//
//		_data[0] = 0xAA;
//		_data[3] = 0xAA;
//		_delay_ms(delay);
//		send_data(_data, LEN);
//
//		_data[1] = 0xAA;
//		_data[4] = 0xAA;
//		_delay_ms(delay);
//		send_data(_data, LEN);
//
//		_data[2] = 0xAA;
//		_data[5] = 0xAA;
//		_delay_ms(delay);
//		send_data(_data, LEN);
	}

	return 0;
}

File Software/ledbox/board/push.h:

/*
 * push.h
 *
 *  Created on: 30.10.2017
 *      Author: fabian
 */

#ifndef PUSH_H_
#define PUSH_H_

#include "avr/io.h"

#define PUSH1 		PC4
#define PUSH2		PC5
#define PUSH_DDR		DDRC
#define PUSH_PIN		PINC
#define PUSH_PORT	PORTC

void push_init();

void push_check(int8_t *push1, int8_t *push2);

#endif /* PUSH_H_ */

## Commit log

2017-10-05 Erste Version des LED Box Prototypen
2017-10-05 LED Vorwiderstände auf E-Reihen angepasst
2017-10-05 Plot verschoben
2017-10-05 Ordner plot in output geändert. BOM hinzugefügt
2017-10-05 Version 1.1: - RGB LED Symbol angepasst - Button und IR LED auf eine vierer Klemmleiste Footprints assoziiert
2017-10-06 Version 2 - Anforderungen für Software hinzugefügt - CSMA/CA anstatt CSMA/CD - Kollisionsdetektion hinzugefügt - Verbinder für IR LED und Button getrennt und unterschiedlich gemacht - zusätzlich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
2017-10-06 Anforderungen Software korrekt benannt
2017-10-06 Software und Buszugriff PDFs getrennt
2017-10-06 LTSpice asc der Bus Kollisionserkennung hinzugefügt
2017-10-07 Exchanged SN75176B with ST485C
2017-10-09 Version 3: - ATmega88 - Schaltplan auf verschiedene sheets aufgeteilt - div. kleine Änderungen
2017-10-15 Board Layout (SMD) fertiggestellt
2017-10-15 Kleine Verbesserungen
2017-10-15 Gerber Dateien erstellt
2017-10-16 Kleine Veränderungen
2017-10-16 Befestigungsbohrungen in Top Paste Layer aufgenommen -> Stencil kann eingespannt werden
2017-10-16 Gerber Dateinamen angepasst
2017-10-16 Dokumentation aktualisiert
2017-10-16 Atmega88 gegen Atmega88A getauscht
2017-10-22 Ordnerstruktur geändert
2017-10-23 Systick added, different PWM resolution extender tested.
2017-10-30 Fitted software to prototype boards
2017-11-21 Started CSMA and BUS development. Added Board peripherals.
2017-11-24 Added two dimensional parity to packet data transmission. Completed CSMA initial states.
2017-11-25 Replaced uart module with more specialized rs485 module for USART peripheral control.
2017-11-26 IR LED modules added
2017-12-18 IR documentation added
2017-12-18 CSMA/CA changed to use IR timer
2018-03-11 Schematic Version 4 Some Software Changes
2018-03-11 Changes to V4 Schematic, new Board design
2018-03-11 Added board plot
2018-03-15 Finished v4 board
2018-03-15 Added version label
2018-03-15 Added V.4 renderings.
2018-04-29 Version 4 Shift Register
2018-05-15 Regenerated schematic plot
2018-05-17 Applied changes for final design, placed test points.
2018-05-17 assigned transistor model
2018-05-17 paralleled RGB leds
2018-05-17 Created final gerber files
2018-05-17 turned data connectors to match cable layout
2018-05-25 paste layer export
2018-05-25 test
2018-05-29 added board plots
2018-05-30 added test software
2018-05-30 added solder manual and test software
2018-05-30 added pin definitions to test software
