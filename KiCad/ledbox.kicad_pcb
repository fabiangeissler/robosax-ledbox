# Repository fabiangeissler/robosax-ledbox

File README.md:

# robosax-ledbox
Bestandteil des Spielfeldes zum RoboSAX Wettbewerb 2018.  

Die Boxen bestehen aus einer RGB LED zur Statusanzeige und einem Button zur Aktivierung durch die Roboter. Zusätzlich enthält jede Box eine infrarot LED in der Nähe des Buttons um Daten an den Roboter zu übermitteln. Die Nutzung der IR LED ist für den Wettbewerbsablauf nicht notwendig, kann aber Vorteile bringen.  

Genauere Informationen zum mechanichen Aufbau, Maße und Datenprotokolle folgen sobald sie festgelegt wurden.

Fabian Geißler  
RoboSAX Team

## KiCad design KiCad/ledbox.kicad_pcb

Parts:
C101: 10u; CP_Radial_D6.3mm_P2.50mm
J101: Add Input; Molex_KK-6410-03_03x2.54mm_Straight
J102: 5V; TerminalBlock_Phoenix_MKDS1.5-2pol
J103: To Master; IDC-Header_2x05_Pitch2.54mm_Straight
J104: Add Output; Molex_KK-6410-03_03x2.54mm_Straight
J105: To Slave; IDC-Header_2x05_Pitch2.54mm_Straight
R101, R102, R103: 120; R_0805
TP101, TP102, TP103, TP104, TP105: Test_Point; TestPoint_Pad_D1.0mm

Connections:
+5V: C101.1, J101.1, J102.2, J104.1; also elsewhere on the board
/BTN_DATA_IN: J105.3, TP103.1; also elsewhere on the board
/BTN_DATA_OUT: J103.3, R101.2, TP104.1
/BTN_LOAD: J103.4, J105.4; also elsewhere on the board
/CLK: J103.9, J105.9, TP101.1; also elsewhere on the board
/IR_CLK: J103.5, J105.5; also elsewhere on the board
/Interface/RGB_OUT: R103.1; also elsewhere on the board
/LED_DATA_IN: J103.1; also elsewhere on the board
/LED_DATA_OUT: J105.1, R102.2, TP105.1
/LED_LOAD: J103.2, J105.2, TP102.1; also elsewhere on the board
/Logic/ADD_IN: J101.2; also elsewhere on the board
/Logic/ADD_OUT: J104.2; also elsewhere on the board
/Logic/BTN_DATA_OUT: R101.1; also elsewhere on the board
/Logic/LED_DATA_OUT: R102.1; also elsewhere on the board
/RGB_IN: J103.7; also elsewhere on the board
/RGB_OUT: J105.7, R103.2
GND: C101.2, J101.3, J102.1, J103.6, J103.8, J103.10, J104.3, J105.6, J105.8, J105.10; also elsewhere on the board

Parts:
C201, C202, C203, C204: 100n; C_0805
D201, D202: LED; LED_D3.0mm
JP201: Single Out; Jumper_SMD_02
JP202: Add Out; Jumper_SMD_02
JP203: Single In; Jumper_SMD_02
JP204: Add In; Jumper_SMD_02
R201, R202: 1k; R_0805
TP201: LED IN; TestPoint_Pad_D1.0mm
TP202, TP203, TP204, TP205, TP206, TP207: Test_Point; TestPoint_Pad_D1.0mm
TP208: LED OUT; TestPoint_Pad_D1.0mm
TP209: ADD BTN; TestPoint_Pad_D1.0mm
TP210: ADD OUT; TestPoint_Pad_D1.0mm
TP211: BTN OUT; TestPoint_Pad_D1.0mm
U201, U202: 74LS175; DIP-16_W7.62mm_LongPads
U203: 74LS00; DIP-14_W7.62mm_LongPads
U204: 74LS126; DIP-14_W7.62mm_LongPads

Connections:
+5V: C201.1, C202.1, C203.1, C204.1, D201.2 (A), D202.2 (A), U201.1 (~Mr), U201.16 (VCC), U202.1 (~Mr), U202.16 (VCC), U203.14 (VCC), U204.14 (VCC); also elsewhere on the board
/BTN_DATA_IN: U204.2; also elsewhere on the board
/BTN_LOAD: U203.9, U203.10, U204.4; also elsewhere on the board
/CLK: U202.9 (Cp); also elsewhere on the board
/IR_CLK: TP202.1, U203.1; also elsewhere on the board
/LED_DATA_IN: TP201.1, U202.4 (D0); also elsewhere on the board
/LED_LOAD: U201.9 (Cp); also elsewhere on the board
/Logic/ADD_IN: TP204.1, U203.4; also elsewhere on the board
/Logic/ADD_OUT: TP207.1, U203.6; also elsewhere on the board
/Logic/BTN_DATA_OUT: JP203.2, JP204.2; also elsewhere on the board
/Logic/BTN_OUT: JP203.1, TP211.1, U202.10 (Q2); also elsewhere on the board
/Logic/IR_LED: TP206.1, U203.3; also elsewhere on the board
/Logic/LED_DATA_OUT: JP201.2, JP202.2; also elsewhere on the board
/Logic/LED_INDICATOR: R201.1, U201.3 (~Q0)
/Logic/LED_INDICATOR_ADD: R202.1, U201.6 (~Q1)
/Logic/LED_OUT: JP201.1, TP208.1, U201.4 (D0), U202.2 (Q0), U202.5 (D1)
/Logic/LED_OUT_ADD: JP202.1, TP210.1, U201.5 (D1), U202.7 (Q1)
GND: C201.2, C202.2, C203.2, C204.2, U201.8 (GND), U201.12 (D2), U201.13 (D3), U202.8 (GND), U203.7 (GND), U204.7 (GND); also elsewhere on the board
unnamed: D201.1 (K), R201.2
unnamed: D202.1 (K), R202.2
unnamed: JP204.1, TP209.1, U202.15 (Q3)
unnamed: TP203.1, U201.2 (Q0), U203.2
unnamed: TP205.1, U201.7 (Q1), U203.5

Parts:
C501, C502, C503: 10u; C_0805
C504: 100n; C_0805
J501: IR LED; Molex_KK-6410-03_03x2.54mm_Straight
JP501: IR 12mA; Jumper_SMD_02
JP502: IR 36mA; Jumper_SMD_02
JP503: IR 76mA; Jumper_SMD_02
Q501: AO3415A; SOT-23
R501, R504: 100; R_0805
R502: 47k; R_0805
R503: 220; R_0805
R505: 47; R_0805
TP501: RGB1; TestPoint_Pad_D1.0mm
TP502: RGB2; TestPoint_Pad_D1.0mm
TP503: IR LED; TestPoint_Pad_D1.0mm
TP504: IR PWM; TestPoint_Pad_D1.0mm
TP505: RGB3; TestPoint_Pad_D1.0mm
U501, U502, U503: WS2812B; LED_WS2812B-PLCC4

Connections:
+5V: C501.1, C502.1, C503.1, C504.1, Q501.2, R502.2, U501.1 (VDD), U502.1 (VDD), U503.1 (VDD); also elsewhere on the board
/Interface/IR_LED_DRV: J501.1, J501.3, R503.2, R504.2, R505.2, TP503.1
/Interface/RGB_OUT: U503.2 (DOUT); also elsewhere on the board
/Logic/IR_LED: R501.2; also elsewhere on the board
/RGB_IN: TP501.1, U501.4 (DIN), U502.4 (DIN), U503.4 (DIN); also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, J501.2, U501.3 (GND), U502.3 (GND), U503.3 (GND); also elsewhere on the board
unnamed: JP501.1, R503.1
unnamed: JP501.2, JP502.2, JP503.2, Q501.3, TP504.1
unnamed: JP502.1, R504.1
unnamed: JP503.1, R505.1
unnamed: Q501.1, R501.1, R502.1
unnamed: TP502.1, U501.2 (DOUT)
unnamed: TP505.1, U502.2 (DOUT)

Parts:
C301: 100n; C_0805
J301: Button; Molex_KK-6410-02_02x2.54mm_Straight
JP301: ~Debounce; Jumper_SMD_02
JP302: Debounce; Jumper_SMD_02
R301: 4k7; R_0805
R302: 47k; R_0805
TP301: BTN ANA; TestPoint_Pad_D1.0mm
TP302: BTN LOAD; TestPoint_Pad_D1.0mm
TP303: ~BTN LOAD; TestPoint_Pad_D1.0mm
TP304: BTN IN; TestPoint_Pad_D1.0mm
U203: 74LS00; DIP-14_W7.62mm_LongPads
U204: 74LS126; DIP-14_W7.62mm_LongPads

Connections:
+5V: R301.1; also elsewhere on the board
/BTN_DATA_IN: U204.2; also elsewhere on the board
/BTN_LOAD: TP302.1, U203.9, U203.10, U203.12, U203.13, U204.4, U204.13; also elsewhere on the board
/Logic/BTN_OUT: U204.9; also elsewhere on the board
GND: C301.2, J301.2; also elsewhere on the board
unnamed: C301.1, JP302.2
unnamed: J301.1, JP301.1, R301.2, R302.2

Parts of its further copies:
C401: 100n; C_0805
J401: Button; Molex_KK-6410-02_02x2.54mm_Straight
JP401: ~Debounce; Jumper_SMD_02
JP402: Debounce; Jumper_SMD_02
R401: 4k7; R_0805
R402: 47k; R_0805
TP401: BTN ANA; TestPoint_Pad_D1.0mm
TP402: BTN LOAD; TestPoint_Pad_D1.0mm
TP403: ~BTN LOAD; TestPoint_Pad_D1.0mm
TP404: BTN IN; TestPoint_Pad_D1.0mm

Connections of its further copies:
+5V: R401.1; also elsewhere on the board
/BTN_LOAD: TP402.1; also elsewhere on the board
GND: C401.2, J401.2; also elsewhere on the board
unnamed: C401.1, JP402.2
unnamed: J401.1, JP401.1, R401.2, R402.2

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
Board: 2 copper layers, 80.0 x 50.0 mm, 83 parts (68 on the bottom side), 46 nets.

## KiCad design KiCad/ledbox_v4.kicad_pcb

Board: 2 copper layers, 80.0 x 50.0 mm, 91 parts (21 on the bottom side), 50 nets.

Parts:
C201, C501, C502, C503: 10u; C_0805
C202, C306, C307: 22p; C_0805
C203: 470p; C_0805
C301, C302, C303, C304, C305, C402, C403, C504: 100n; C_0805
C401: 4u7; CP_Radial_D5.0mm_P2.00mm
C404: 47u; CP_Radial_D6.3mm_P2.50mm
CON301: AVR_ISP; IDC-Header_2x03_Pitch2.54mm_Straight
D201, D202, D401: 1N4148; D_SOD-123
D402: PWR; LED_D3.0mm
D403: PMEG4010ER; D_SOD-123
D501: LED1; LED_D3.0mm
D502: LED2; LED_D3.0mm
J201: Bus; IDC-Header_2x05_Pitch2.54mm_Straight
J301: Power B; Socket_Strip_Straight_2x06_Pitch2.54mm
J302: Port B; Socket_Strip_Straight_1x06_Pitch2.54mm
J303: Spare; Socket_Strip_Straight_1x02_Pitch2.54mm
J304: UART; Socket_Strip_Straight_1x03_Pitch2.54mm
J305: ADC6; Socket_Strip_Straight_1x03_Pitch2.54mm
J306: ADC7; Socket_Strip_Straight_1x03_Pitch2.54mm
J401: 6.5V-12V; TerminalBlock_MetzConnect_Type055_RT01502HDWU_Pitch5.00mm
J402: 5V; TerminalBlock_MetzConnect_Type055_RT01502HDWU_Pitch5.00mm
J501: IR LED; Molex_KK-6410-03_03x2.54mm_Straight
J502: Button; Molex_KK-6410-02_02x2.54mm_Straight
JP201: COMMA PU; Jumper_SMD_02
JP202: TERM; Jumper_SMD_02
JP203: COMMB PD; Jumper_SMD_02
JP501: IR 12mA; Jumper_SMD_02
JP502: IR 24mA; Jumper_SMD_02
JP503: IR 48mA; Jumper_SMD_02
Q501: NTR4003N; SOT-23
R201, R506, R507, R508, R509: 10k; R_0805
R202, R204, R301, R302, R303: 1k; R_0805
R203, R504: 150; R_0805
R205, R501: 100; R_0805
R206: 22k; R_0805
R207: 3k3; R_0805
R208, R401: 2k2; R_0805
R502: 100k; R_0805
R503: 300; R_0805
R505: 75; R_0805
R510, R511: 430; R_0805
SW501: Reset; SW_PUSH_6mm_h5mm
SW502: Push 1; SW_PUSH_6mm_h5mm
SW503: Push 2; SW_PUSH_6mm_h5mm
TP201: TXEN; TEST_10
TP202: UART TX; TEST_10
TP203: Comm A; TEST_10
TP204: Comm B; TEST_10
TP205: UART RX; TEST_10
TP206: CD Out; TEST_10
TP207: CD Ref; TEST_10
TP401: VIN; TEST_10
TP402: 5V; TEST_10
TP501: RGB1; TEST_10
TP502: RGB2; TEST_10
TP503: IR LED; TEST_10
TP504: IR PWM; TEST_10
TP505: RGB3; TEST_10
U201: ST485C; SOIC-8_3.9x4.9mm_Pitch1.27mm
U301: ATMEGA88A-AU; TQFP-32_7x7mm_Pitch0.8mm
U401: AZ1117-5.0; SOT-223-3_TabPin2
U501, U502: WS2812B; LED_WS2812B-PLCC4
U503: 3xWS2812B; LED_WS2812B-PLCC4
Y301: 20MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C201.1, C302.1, C303.1, C304.1, C305.1, C403.1, C404.1, C501.1, C502.1, C503.1, C504.1, CON301.2, D401.2, D402.2, D501.2, D502.2, J201.1, J201.3, J201.8, J201.10, J301.1, J301.3, J301.5, J301.7, J301.9, J301.11, J305.1, J306.1, J402.1, J501.1, J501.3, R202.1, R207.1, R506.1, R507.1, R508.1, R509.1, TP402.1, U201.8, U301.4, U301.6, U301.18, U401.2, U501.1, U502.1, U503.1
+12V: C401.1, C402.1, D401.1, D403.1, TP401.1, U401.3
/Bus/AIN0: C202.1, R205.1, R206.1, TP206.1, U301.10
/Bus/AIN1: C203.1, R207.2, R208.1, TP207.1, U301.11
/Bus/COMM_A: D201.2, J201.5, JP201.2, R203.1, TP203.1, U201.6
/Bus/COMM_B: D202.2, J201.6, JP202.2, JP203.1, TP204.1, U201.7
/Bus/RX: J304.1, TP205.1, U201.1, U301.30
/Bus/TX: J304.2, TP202.1, U201.4, U301.31
/Bus/TX_EN: R201.2, TP201.1, U201.3, U301.23
/Controller/ADC6: J305.2, U301.19
/Controller/ADC7: J306.2, U301.22
/Controller/BTN: J502.1, R506.2, U301.2
/Controller/LED1: R510.2, U301.25
/Controller/LED2: R511.2, U301.26
/Controller/LED_IR: R501.2, U301.9
/Controller/MISO: CON301.1, R303.2, U301.16
/Controller/MOSI: CON301.4, R301.2, U301.15
/Controller/PB0: J302.1, U301.12
/Controller/PB1: J302.2, U301.13
/Controller/PB2: J302.3, U301.14
/Controller/PB3: J302.4, R301.1
/Controller/PB4: J302.5, R303.1
/Controller/PB5: J302.6, R302.1
/Controller/PC1: J303.1, U301.24
/Controller/PD2: J303.2, U301.32
/Controller/PUSH1: R508.2, SW502.1, U301.27
/Controller/PUSH2: R509.2, SW503.1, U301.28
/Controller/RGB_D: TP501.1, U301.1, U501.4
/Controller/SCK: CON301.3, R302.2, U301.17
/Controller/XTAL1: C306.1, U301.7, Y301.1
/Controller/XTAL2: C307.1, U301.8, Y301.2
/Controller/~RESET: CON301.5, R507.2, SW501.1, U301.29
/Interface/IR_LED_DRV: J501.2, R503.2, R504.2, R505.2, TP503.1
GND: C201.2, C202.2, C203.2, C301.1, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C401.2, C402.2, C403.2, C404.2, C501.2, C502.2, C503.2, C504.2, CON301.6, J201.2, J201.4, J201.7, J201.9, J301.2, J301.4, J301.6, J301.8, J301.10, J301.12, J304.3, J305.3, J306.3, J401.2, J402.2, J502.2, Q501.2, R201.1, R204.2, R206.2, R208.2, R401.2, R502.1, SW501.2, SW502.2, SW503.2, U201.2, U201.5, U301.3, U301.5, U301.21, U401.1, U501.3, U502.3, U503.3
unnamed: C301.2, U301.20
unnamed: D201.1, D202.1, R205.2
unnamed: D402.1, R401.1
unnamed: D403.2, J401.1
unnamed: D501.1, R510.1
unnamed: D502.1, R511.1
unnamed: JP201.1, R202.2
unnamed: JP202.1, R203.2
unnamed: JP203.2, R204.1
unnamed: JP501.1, R503.1
unnamed: JP501.2, JP502.2, JP503.2, Q501.3, TP504.1
unnamed: JP502.1, R504.1
unnamed: JP503.1, R505.1
unnamed: Q501.1, R501.1, R502.2
unnamed: TP502.1, U501.2, U502.4
unnamed: TP505.1, U502.2, U503.4

File ledbox-bom-v3.xlsx:

Table 1
Item | Qty | Reference(s) | Value | LibPart | Footprint |  | Alternative | Assembly | Elecrow ID | Elecrow Part | Elecrow Value | Part ID | Digikey | Mouser | Comment
1 | 4 | C201; C501; C502; C503 | 10u | device:C | Capacitors_SMD:C_0805 | 0805 |  |  | 16532 | C15850 | 10uF (106) ±10% 25V
2 | 3 | C202; C306; C307 | 22p | device:C | Capacitors_SMD:C_0805 | 0805 |  |  | 2156 | C1804 | 22pF (220) ±5% 50V
3 | 1 | C203 | 470p | device:C | Capacitors_SMD:C_0805 | 0805 |  |  | 2095 | C1743 | 470pF (471) ±10% 50V
4 | 8 | C301; C302; C303; C304; C305; C402; C403; C504 | 100n | device:C | Capacitors_SMD:C_0805 | 0805 |  |  | 50686 | C49678 | 100nF(104) ±10% 50V
5 | 1 | C401 | 4u7 25V | device:CP | Capacitors_THT:CP_Radial_D5.0mm_P2.00mm | P2.00mm |  | DNP
6 | 1 | C404 | 47u 16V | device:CP | Capacitors_THT:CP_Radial_D6.3mm_P2.50mm | P2.50mm |  |  |  |  |  | 47µF 16V aluminum electrolytic capacitor | https://www.digikey.de/product-detail/de/panasonic-electroni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 | https://www.mouser.de/ProductDetail/Panasonic/ECA-1CM470I?qs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 | Or similar part
7 | 1 | CON301 | AVR_ISP | atmel:AVR-ISP-6 | Connectors_IDC:IDC-Header_2x03_Pitch2.54mm_Straight | Straight |  |  |  |  |  | IDC-Header 02x03 Pitch 2.54mm Straight | https://www.digikey.de/product-detail/de/amphenol-fci/75869-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 | https://www.mouser.de/ProductDetail/Wurth-Electronics/612006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 | Or similar part
8 | 3 | D201; D202; D401 | 1N4148 | device:D | Diodes_SMD:D_SOD-123 | SOD-123 |  |  |  |  |  | 1N4148W-7-F | https://www.digikey.de/product-detail/de/diodes-incorporated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 | https://eu.mouser.com/ProductDetail/Diodes-Incorporated/1N41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
9 | 2 | D402; D502 | LED2 | device:LED | LEDs:LED_D3.0mm | D3.0mm |  | DNP
10 | 1 | D403 | PMEG4010ER | device:D_Schottky | Diodes_SMD:D_SOD-123 | SOD-123 | MBR140ESFT3G |  |  |  |  | PMEG4010ER,115 | https://www.digikey.de/product-detail/de/nexperia-usa-inc/PM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 | https://www.mouser.de/ProductDetail/Nexperia/PMEG4010ER115?q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
11 | 1 | D501 | LED1 | device:LED | LEDs:LED_D3.0mm | D3.0mm |  | DNP
12 | 1 | J201 | Bus | Connector:Conn_02x05_Odd_Even | Connectors_IDC:IDC-Header_2x05_Pitch2.54mm_Straight | Straight |  |  |  |  |  | IDC-Header 02x05 Pitch 2.54mm Straight | https://www.digikey.de/product-detail/de/on-shore-technology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 | https://www.mouser.de/ProductDetail/Wurth-Electronics/612010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 | Or similar part
13 | 1 | J301 | Power B | Connector:Conn_02x06_Odd_Even | Socket_Strips:Socket_Strip_Straight_2x06_Pitch2.54mm | Pitch2.54mm |  | DNP
14 | 1 | J302 | Port B | Connector:Conn_01x06 | Socket_Strips:Socket_Strip_Straight_1x06_Pitch2.54mm | Pitch2.54mm |  | DNP
15 | 1 | J303 | Spare | Connector:Conn_01x02 | Socket_Strips:Socket_Strip_Straight_1x02_Pitch2.54mm | Pitch2.54mm |  | DNP
16 | 1 | J304 | UART | Connector:Conn_01x03 | Socket_Strips:Socket_Strip_Straight_1x03_Pitch2.54mm | Pitch2.54mm |  | DNP
17 | 1 | J305 | ADC6 | Connector:Conn_01x03 | Socket_Strips:Socket_Strip_Straight_1x03_Pitch2.54mm | Pitch2.54mm |  | DNP
18 | 1 | J306 | ADC7 | Connector:Conn_01x03 | Socket_Strips:Socket_Strip_Straight_1x03_Pitch2.54mm | Pitch2.54mm |  | DNP
19 | 1 | J401 | 6.5V-12V | Connector:Conn_01x02 | TerminalBlock_MetzConnect:TerminalBlock_MetzConnect_Type055_RT01502HDWU_Pitch5.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 | Pitch5.00mm |  | DNP
20 | 1 | J402 | 5V | Connector:Conn_01x02 | TerminalBlock_MetzConnect:TerminalBlock_MetzConnect_Type055_RT01502HDWU_Pitch5.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 | Pitch5.00mm |  |  |  |  |  | Terminal 2 Pin Pitch 5mm | https://www.digikey.de/product-detail/de/amphenol-anytek/VI0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 | https://www.mouser.de/ProductDetail/Bussmann-Eaton/EM367502?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 | Or similar part
21 | 1 | J501 | IR LED | Connector:Conn_01x03 | Connectors_Molex:Molex_KK-6410-03_03x2.54mm_Straight | Straight |  |  |  |  |  | Molex locking header Pitch 2.54mm 3 Pin | https://www.digikey.de/product-detail/de/sullins-connector-s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 | https://www.mouser.de/ProductDetail/Molex/22-28-0030?qs=sGAE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 | Or similar part
22 | 1 | J502 | Button | Connector:Conn_01x02 | Connectors_Molex:Molex_KK-6410-02_02x2.54mm_Straight | Straight |  |  |  |  |  | Molex locking header Pitch 2.54mm 2 Pin | https://www.digikey.de/product-detail/de/sullins-connector-s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 | https://www.mouser.de/ProductDetail/Molex/22-28-0020?qs=sGAE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 | Or similar part
23 | 1 | Q501 | NTR4003N | device:Q_NMOS_GSD | TO_SOT_Packages_SMD:SOT-23 | SMD:SOT-23 | Logic Level N-ch 500mA MOS |  |  |  |  | NTR4003NT1G | https://www.digikey.de/product-detail/de/on-semiconductor/NT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 | https://www.mouser.de/ProductDetail/ON-Semiconductor/NTR4003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
24 | 5 | R201; R506; R507; R508; R509 | 10k | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 18102 | C17414 | 10KΩ (1002) ±1%
25 | 5 | R202; R204; R301; R302; R303 | 1k | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 18201 | C17513 | 1KΩ (1001) ±1%
26 | 1 | R203 | 150Ω | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 18159 | C17471 | 150Ω (1500) ±1%
27 | 3 | R205; R501; R504 | 100Ω | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 18096 | C17408 | 100Ω (1000) ±1%
28 | 1 | R206 | 22k | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 18248 | C17560 | 22KΩ (2202) ±1%
29 | 1 | R207 | 3.3k | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 26753 | C26010 | 3.3KΩ (3301) ±1%
30 | 2 | R208; R401 | 2.2k | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 18208 | C17520 | 2.2KΩ (2201) ±1%
31 | 1 | R502 | 100k | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 18095 | C17407 | 100KΩ (1003) ±1%
32 | 1 | R503 | 220Ω | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 18245 | C17557 | 220Ω (2200) ±1%
33 | 1 | R505 | 47Ω | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 18402 | C17714 | 47Ω (47R0) ±1%
34 | 2 | R510; R511 | 470Ω | device:R | Resistors_SMD:R_0805 | 0805 |  |  | 18398 | C17710 | 470Ω (4700) ±1%
35 | 1 | SW501 | Reset | Switch:SW_Push | Buttons_Switches_THT:SW_PUSH_6mm_h5mm | h5mm |  | DNP
36 | 1 | SW502 | Push 1 | Switch:SW_Push | Buttons_Switches_THT:SW_PUSH_6mm_h5mm | h5mm |  | DNP
37 | 1 | SW503 | Push 2 | Switch:SW_Push | Buttons_Switches_THT:SW_PUSH_6mm_h5mm | h5mm |  | DNP
38 | 1 | U201 | ST485C | ledbox-newsymbols:SN75176B | Housings_SOIC:SOIC-8_3.9x4.9mm_Pitch1.27mm | Pitch1.27mm |  |  |  |  |  | ST485CDR | https://www.digikey.de/product-detail/de/stmicroelectronics/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 | https://www.mouser.de/ProductDetail/STMicroelectronics/ST485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
39 | 1 | U301 | ATMEGA88A-AU | atmel:ATMEGA88A-AU | Housings_QFP:TQFP-32_7x7mm_Pitch0.8mm | Pitch0.8mm |  |  |  |  |  | ATMEGA88A-AU | https://www.digikey.de/product-detail/de/microchip-technolog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 | https://www.mouser.de/ProductDetail/Microchip-Technology-Atm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
40 | 1 | U401 | AZ1117-5.0 | regul:AZ1117-5.0 | TO_SOT_Packages_SMD:SOT-223-3_TabPin2 | TabPin2 |  | DNP
41 | 3 | U501; U502; U503 | WS2812B | worldsemi:WS2812B | LEDs:LED_WS2812B-PLCC4 | WS2812B-PLCC4 |  |  |  |  |  | WS2812B | - | -
42 | 1 | Y301 | 20MHz | device:Crystal | Crystals:Crystal_HC49-U_Vertical | Vertical |  |  |  |  |  | CRYSTAL 20.0000MHZ 20PF | https://www.digikey.de/product-detail/de/txc-corporation/9B-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 | https://www.mouser.de/ProductDetail/Fox/FOXSLF-200-20?qs=sGA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 | Or similar part

## KiCad design LED Box KiCad/ledbox.kicad_pcb

Parts:
C201: 10u; C_0805
C202: 22p; C_0805
C203: 470p; C_0805
D201, D202: 1N4148; D_SOD-123
J201: Bus; Pin_Header_Straight_2x05
R201, R203: 1k; R_0805
R202: 150; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R204: 10k; R_0805
R205: 100; R_0805
R206: 22k; R_0805
R207: 3k3; R_0805
R208: 2k2; R_0805
U201: ST485C; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
+5V: C201.1, J201.1, J201.3, J201.8, J201.10, R201.1, R207.1, U201.8 (VCC); also elsewhere on the board
/Bus/AIN0: C202.1, R205.1, R206.1; also elsewhere on the board
/Bus/AIN1: C203.1, R207.2, R208.1; also elsewhere on the board
/Bus/COMM_A: D201.2 (A), J201.5, R201.2, R202.1, U201.6 (A)
/Bus/COMM_B: D202.2 (A), J201.6, R202.2, R203.1, U201.7 (B)
/Bus/RX: U201.1 (R); also elsewhere on the board
/Bus/TX: U201.4 (D); also elsewhere on the board
/Bus/TX_EN: R204.2, U201.3 (DE); also elsewhere on the board
GND: C201.2, C202.2, C203.2, J201.2, J201.4, J201.7, J201.9, R203.2, R204.1, R206.2, R208.2, U201.2 (~RE), U201.5 (GND); also elsewhere on the board
unnamed: D201.1 (K), D202.1 (K), R205.2

Notes on the sheet:
Bus Kollisionsdetektor Wenn der high Pegel auf dem Bus rund 3V unterschreitet liegt eine Kollision vor. Da der high level Treiber schwächer ist als der low level Treiber wird dieser Pegel ausgewertet (vgl. DS S.12, Fig.12 und Fig.13).
2,4V
Erster und letzter Teilnehmer am Bus benötigen eine Abschlussimpedanz Bei Flachbandkabel zwischen 100Ω und 200Ω (differentiell). Angegeben: 104Ω (AWG 28, GSG). Kann evtl. über Klemmleiste oder Pinheader befestigt werden.
R201 und R203 werden genutzt um einen definierten Zustand auf der Leitung zu schaffen, wenn kein Sender aktiv ist. Müssen nur auf einer Einheit im Bus vorhanden sein (=> Auswerteeineit?).
Neues Bauteil: ST485C - viel geringerer Ruhestrom als SN75176 Bei diesem Sender ist der high side Treiber schwächer als der low side Treiber, daher muss die CD Schaltung umgedreht werden.
Spannungsversorgung und Bus über 10 Pol Flachbandkabel, einmal rund ums Spielfeld. Auswerteeinheit (1x pro Spielfeld) speist Spannungsversorgung ein und bildet Schnittstelle zur Auswertung und Datenübergabe bzw. Einstellung.
